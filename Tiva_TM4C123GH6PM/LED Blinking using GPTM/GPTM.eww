<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LED Blink using GPMT_polling.ewp</path>
    </project>
    <batchBuild />
</workspace>
