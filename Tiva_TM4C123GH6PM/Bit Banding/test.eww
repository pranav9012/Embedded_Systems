<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bit_banding.ewp</path>
    </project>
    <batchBuild />
</workspace>
