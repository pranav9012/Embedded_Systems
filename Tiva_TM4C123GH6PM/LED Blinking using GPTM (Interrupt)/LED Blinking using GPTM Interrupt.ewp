# IAR project LED Blinking using GPTM Interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: E:\Github\Projects\Embedded_systems\Tiva_TM4C123GH6PM\LED Blinking using GPTM (Interrupt)\inc; E:\Github\Projects\Embedded_systems\Tiva_TM4C123GH6PM\LED Blinking using GPTM (Interrupt)\Include_Core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c startup_TM4C123.s
    src/: system_TM4C123.c
