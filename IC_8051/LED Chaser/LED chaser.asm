ORG 00
PART1: MOV A, #0AAH
 MOV P1, A
 ACALL DELAY1
 CPL A
PART2:MOV P1,  A
 ACALL DELAY1

MOV A, #7EH
PART3: MOV P1, A
 ACALL DELAY1 

MOV A, #0BDH
PART4: MOV P1, A
 ACALL DELAY1

MOV A, #0DBH
PART5: MOV P1, A
 ACALL DELAY1

MOV A, #0E7H
PART6: MOV P1, A
 ACALL DELAY1

MOV A, #0DBH
PART5R: MOV P1, A
 ACALL DELAY1

MOV A, #0BDH
PART4R: MOV P1, A
 ACALL DELAY1

MOV A, #7EH
PART3R: MOV P1, A
 ACALL DELAY1

MOV A, #0F0H
PART7: MOV P1, A
 ACALL DELAY1

MOV A, #00FH
PART8: MOV P1, A
 ACALL DELAY1

 ACALL PART1
ORG 300
DELAY1: MOV R5, #05H
AGAIN: DJNZ R5, AGAIN
RET
END
